# Keil uVision project task no 11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: task no 11 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: task11.c
