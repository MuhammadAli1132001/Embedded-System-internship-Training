# Keil uVision project task 16b.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: task 16b +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcdC.c LCDh.h i2c.h i2c.c
