# Keil uVision project task n0 18_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: task n0 18_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EEPROM.c lcdC.c LCDh.h
